<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Timerss_Tiva_C_Total.ewp</path>
    </project>
    <batchBuild />
</workspace>
